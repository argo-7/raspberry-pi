## kernel_4.19.113-v7+/drivers/argo/Kconfig
```kconfig
# Simple configuration for the new driver.

config MAIN
tristate "my driver"
depends on ARM
default y if ARM
help
  my driver module.
```
